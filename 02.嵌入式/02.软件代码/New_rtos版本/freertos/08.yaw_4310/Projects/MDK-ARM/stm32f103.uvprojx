# Keil uVision project stm32f103.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers;..\..\Users;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\systime;..\..\Drivers\SYSTEM\uart1;..\..\Drivers\SYSTEM\sys;..\..\Drivers\BSP\LED;..\..\Drivers\SYSTEM\iic;..\..\Drivers\BSP\KEY;..\..\Drivers\BSP\OLED;..\..\Drivers\BSP\NRF24L01;..\..\Drivers\BSP\AS5600;..\..\Drivers\BSP\PWM;..\..\Drivers\BSP\Foc;..\..\Drivers\BSP\adc;..\..\Drivers\BSP\CAN;..\..\Drivers\BSP\DMA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group User
    ../../Users/: main.c stm32f1xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: LED.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/OLED/: oled.c
    ../../Drivers/BSP/NRF24L01/: NRF24L01.c
    ../../Drivers/BSP/AS5600/: as5600.c
    ../../Drivers/BSP/Foc/: Data.c FOC.c Lowpass.c Motor.c Pid.c
    ../../Drivers/BSP/PWM/: pwm.c
    ../../Drivers/BSP/adc/: adc.c
    ../../Drivers/BSP/DMA/: dma.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/systime/: systime.c
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/uart1/: uart1.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/iic/: iic.c
    ../../Drivers/BSP/CAN/: can.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_spi.c
